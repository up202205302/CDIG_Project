options:
  parameters:
    generate_options: qt_gui
    id: project_802_11a
    output_language: python
    title: CDIG - 802.11a/g/p RX
  states: {}

blocks:
- name: LO_freq
  id: variable_qtgui_chooser
  parameters:
    label: Center Frequency / 802.11 Channel
    labels: '[''Channel 1   | 802.11g | 2.412GHz'',''Channel 2   | 802.11g | 2.417GHz'',''Channel 3   | 802.11g | 2.422GHz'',''Channel 4   | 802.11g | 2.427GHz'',''Channel 5   | 802.11g | 2.432GHz'',''Channel 6   | 802.11g | 2.437GHz'',''Channel 7   | 802.11g | 2.442GHz'',''Channel 8   | 802.11g | 2.447GHz'',''Channel 9   | 802.11g | 2.452GHz'',''Channel 10| 802.11g | 2.457GHz'',''Channel 11| 802.11g | 2.462GHz'',''Channel 12| 802.11g | 2.467GHz'',''Channel 13| 802.11g | 2.472GHz'',''Channel 36| 802.11a | 5.180GHz'',''Channel 40| 802.11a | 5.200GHz'',''Channel 44| 802.11a | 5.220GHz'',''Channel 48| 802.11a | 5.240GHz'',''Channel 52| 802.11a | 5.260GHz'',''Channel 56| 802.11a | 5.280GHz'',''Channel 60| 802.11a | 5.300GHz'',''Channel 64| 802.11a | 5.320GHz'',''Channel 100| 802.11a | 5.500GHz'',''Channel 104| 802.11a | 5.520GHz'',''Channel 108| 802.11a | 5.540GHz'',''Channel 112| 802.11a | 5.560GHz'',''Channel 116| 802.11a | 5.580GHz'',''Channel 120| 802.11a | 5.600GHz'',''Channel 124| 802.11a | 5.620GHz'',''Channel 128| 802.11a | 5.640GHz'',''Channel 132| 802.11a | 5.660GHz'',''Channel 136| 802.11a | 5.680GHz'',''Channel 140| 802.11a | 5.700GHz'',''Channel 144| 802.11a | 5.720GHz'',''Channel 149| 802.11a | 5.745GHz'',''Channel 153| 802.11a | 5.765GHz'',''Channel 157| 802.11a | 5.785GHz'',''Channel 161| 802.11a | 5.805GHz'',''Channel 165| 802.11a | 5.825GHz'',''Channel 172| 802.11p | 5.860GHz'',''Channel 174| 802.11p | 5.870GHz'',''Channel 175| 802.11p | 5.875GHz'',''Channel 176| 802.11p | 5.880GHz'',''Channel 177| 802.11p | 5.885GHz'',''Channel 178| 802.11p | 5.890GHz'',''Channel 179| 802.11p | 5.895GHz'',''Channel 180| 802.11p | 5.900GHz'',''Channel 181| 802.11p | 5.905GHz'',''Channel 182| 802.11p | 5.910GHz'',''Channel 184| 802.11p | 5.920GHz'']'
    num_opts: '0'
    options: '[2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000, 2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000, 2472000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000, 5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000, 5860000000, 5870000000, 5875000000, 5880000000, 5885000000, 5890000000, 5895000000, 5900000000, 5905000000, 5910000000, 5920000000]'
    type: int
    value: '2412000000'
  states: {}
- name: fft_window
  id: variable_qtgui_chooser
  parameters:
    label: FFT Window
    label0: Rectangular Window
    label1: 'Blackman-Harris '
    labels: '[''Channel 1   | 802.11g | 2.412GHz'',''Channel 2   | 802.11g | 2.417GHz'',''Channel 3   | 802.11g | 2.422GHz'',''Channel 4   | 802.11g | 2.427GHz'',''Channel 5   | 802.11g | 2.432GHz'',''Channel 6   | 802.11g | 2.437GHz'',''Channel 7   | 802.11g | 2.442GHz'',''Channel 8   | 802.11g | 2.447GHz'',''Channel 9   | 802.11g | 2.452GHz'',''Channel 10| 802.11g | 2.457GHz'',''Channel 11| 802.11g | 2.462GHz'',''Channel 12| 802.11g | 2.467GHz'',''Channel 13| 802.11g | 2.472GHz'',''Channel 36| 802.11a | 5.180GHz'',''Channel 40| 802.11a | 5.200GHz'',''Channel 44| 802.11a | 5.220GHz'',''Channel 48| 802.11a | 5.240GHz'',''Channel 52| 802.11a | 5.260GHz'',''Channel 56| 802.11a | 5.280GHz'',''Channel 60| 802.11a | 5.300GHz'',''Channel 64| 802.11a | 5.320GHz'',''Channel 100| 802.11a | 5.500GHz'',''Channel 104| 802.11a | 5.520GHz'',''Channel 108| 802.11a | 5.540GHz'',''Channel 112| 802.11a | 5.560GHz'',''Channel 116| 802.11a | 5.580GHz'',''Channel 120| 802.11a | 5.600GHz'',''Channel 124| 802.11a | 5.620GHz'',''Channel 128| 802.11a | 5.640GHz'',''Channel 132| 802.11a | 5.660GHz'',''Channel 136| 802.11a | 5.680GHz'',''Channel 140| 802.11a | 5.700GHz'',''Channel 144| 802.11a | 5.720GHz'',''Channel 149| 802.11a | 5.745GHz'',''Channel 153| 802.11a | 5.765GHz'',''Channel 157| 802.11a | 5.785GHz'',''Channel 161| 802.11a | 5.805GHz'',''Channel 165| 802.11a | 5.825GHz'',''Channel 172| 802.11p | 5.860GHz'',''Channel 174| 802.11p | 5.870GHz'',''Channel 175| 802.11p | 5.875GHz'',''Channel 176| 802.11p | 5.880GHz'',''Channel 177| 802.11p | 5.885GHz'',''Channel 178| 802.11p | 5.890GHz'',''Channel 179| 802.11p | 5.895GHz'',''Channel 180| 802.11p | 5.900GHz'',''Channel 181| 802.11p | 5.905GHz'',''Channel 182| 802.11p | 5.910GHz'',''Channel 184| 802.11p | 5.920GHz'']'
    num_opts: '2'
    option0: window.rectangular(64)
    option1: window.blackmanharris(64)
    options: '[2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000, 2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000, 2472000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000, 5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000, 5860000000, 5870000000, 5875000000, 5880000000, 5885000000, 5890000000, 5895000000, 5900000000, 5905000000, 5910000000, 5920000000]'
    type: raw
    value: window.rectangular(64)
    widget: radio_buttons
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: SDR RX Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sampling Rate (MHz)
    label0: 20MHz
    label1: 10MHz
    labels: '[''Channel 1   | 802.11g | 2.412GHz'',''Channel 2   | 802.11g | 2.417GHz'',''Channel 3   | 802.11g | 2.422GHz'',''Channel 4   | 802.11g | 2.427GHz'',''Channel 5   | 802.11g | 2.432GHz'',''Channel 6   | 802.11g | 2.437GHz'',''Channel 7   | 802.11g | 2.442GHz'',''Channel 8   | 802.11g | 2.447GHz'',''Channel 9   | 802.11g | 2.452GHz'',''Channel 10| 802.11g | 2.457GHz'',''Channel 11| 802.11g | 2.462GHz'',''Channel 12| 802.11g | 2.467GHz'',''Channel 13| 802.11g | 2.472GHz'',''Channel 36| 802.11a | 5.180GHz'',''Channel 40| 802.11a | 5.200GHz'',''Channel 44| 802.11a | 5.220GHz'',''Channel 48| 802.11a | 5.240GHz'',''Channel 52| 802.11a | 5.260GHz'',''Channel 56| 802.11a | 5.280GHz'',''Channel 60| 802.11a | 5.300GHz'',''Channel 64| 802.11a | 5.320GHz'',''Channel 100| 802.11a | 5.500GHz'',''Channel 104| 802.11a | 5.520GHz'',''Channel 108| 802.11a | 5.540GHz'',''Channel 112| 802.11a | 5.560GHz'',''Channel 116| 802.11a | 5.580GHz'',''Channel 120| 802.11a | 5.600GHz'',''Channel 124| 802.11a | 5.620GHz'',''Channel 128| 802.11a | 5.640GHz'',''Channel 132| 802.11a | 5.660GHz'',''Channel 136| 802.11a | 5.680GHz'',''Channel 140| 802.11a | 5.700GHz'',''Channel 144| 802.11a | 5.720GHz'',''Channel 149| 802.11a | 5.745GHz'',''Channel 153| 802.11a | 5.765GHz'',''Channel 157| 802.11a | 5.785GHz'',''Channel 161| 802.11a | 5.805GHz'',''Channel 165| 802.11a | 5.825GHz'',''Channel 172| 802.11p | 5.860GHz'',''Channel 174| 802.11p | 5.870GHz'',''Channel 175| 802.11p | 5.875GHz'',''Channel 176| 802.11p | 5.880GHz'',''Channel 177| 802.11p | 5.885GHz'',''Channel 178| 802.11p | 5.890GHz'',''Channel 179| 802.11p | 5.895GHz'',''Channel 180| 802.11p | 5.900GHz'',''Channel 181| 802.11p | 5.905GHz'',''Channel 182| 802.11p | 5.910GHz'',''Channel 184| 802.11p | 5.920GHz'']'
    num_opts: '2'
    option0: '20000000'
    option1: '10000000'
    options: '[2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000, 2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000, 2472000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000, 5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000, 5860000000, 5870000000, 5875000000, 5880000000, 5885000000, 5890000000, 5895000000, 5900000000, 5905000000, 5910000000, 5920000000]'
    type: real
    value: '20000000'
    widget: radio_buttons
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Detection Threshold
    min_len: '50'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.56'
  states: {}
- name: update_time
  id: variable_qtgui_chooser
  parameters:
    label: Refresh Time (s)
    label0: 1s
    label1: 100ms
    label2: 10ms
    label3: 1ms
    labels: '[''Channel 1   | 802.11g | 2.412GHz'',''Channel 2   | 802.11g | 2.417GHz'',''Channel 3   | 802.11g | 2.422GHz'',''Channel 4   | 802.11g | 2.427GHz'',''Channel 5   | 802.11g | 2.432GHz'',''Channel 6   | 802.11g | 2.437GHz'',''Channel 7   | 802.11g | 2.442GHz'',''Channel 8   | 802.11g | 2.447GHz'',''Channel 9   | 802.11g | 2.452GHz'',''Channel 10| 802.11g | 2.457GHz'',''Channel 11| 802.11g | 2.462GHz'',''Channel 12| 802.11g | 2.467GHz'',''Channel 13| 802.11g | 2.472GHz'',''Channel 36| 802.11a | 5.180GHz'',''Channel 40| 802.11a | 5.200GHz'',''Channel 44| 802.11a | 5.220GHz'',''Channel 48| 802.11a | 5.240GHz'',''Channel 52| 802.11a | 5.260GHz'',''Channel 56| 802.11a | 5.280GHz'',''Channel 60| 802.11a | 5.300GHz'',''Channel 64| 802.11a | 5.320GHz'',''Channel 100| 802.11a | 5.500GHz'',''Channel 104| 802.11a | 5.520GHz'',''Channel 108| 802.11a | 5.540GHz'',''Channel 112| 802.11a | 5.560GHz'',''Channel 116| 802.11a | 5.580GHz'',''Channel 120| 802.11a | 5.600GHz'',''Channel 124| 802.11a | 5.620GHz'',''Channel 128| 802.11a | 5.640GHz'',''Channel 132| 802.11a | 5.660GHz'',''Channel 136| 802.11a | 5.680GHz'',''Channel 140| 802.11a | 5.700GHz'',''Channel 144| 802.11a | 5.720GHz'',''Channel 149| 802.11a | 5.745GHz'',''Channel 153| 802.11a | 5.765GHz'',''Channel 157| 802.11a | 5.785GHz'',''Channel 161| 802.11a | 5.805GHz'',''Channel 165| 802.11a | 5.825GHz'',''Channel 172| 802.11p | 5.860GHz'',''Channel 174| 802.11p | 5.870GHz'',''Channel 175| 802.11p | 5.875GHz'',''Channel 176| 802.11p | 5.880GHz'',''Channel 177| 802.11p | 5.885GHz'',''Channel 178| 802.11p | 5.890GHz'',''Channel 179| 802.11p | 5.895GHz'',''Channel 180| 802.11p | 5.900GHz'',''Channel 181| 802.11p | 5.905GHz'',''Channel 182| 802.11p | 5.910GHz'',''Channel 184| 802.11p | 5.920GHz'']'
    num_opts: '4'
    option0: '1'
    option1: '0.1'
    option2: '0.01'
    option3: '0.001'
    options: '[2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000, 2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000, 2472000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000, 5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000, 5860000000, 5870000000, 5875000000, 5880000000, 5885000000, 5890000000, 5895000000, 5900000000, 5905000000, 5910000000, 5920000000]'
    type: real
    value: '1'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/joao/Documents/feup/masters/1st/1sem/cdig/project/project_git/week7/wireshark_captures/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joao/Documents/feup/masters/1st/1sem/cdig/project/Wifi_Project_Baseband_recordings/Sample1_20MHz_Channel36.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: fft_window
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: fff
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    bw: samp_rate
    debug: 'False'
    freq: LO_freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: threshold
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: LO_freq
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: divide
    type: float
  states: {state: disabled}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: fir_filter
    type: complex
  states: {state: disabled}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: delay
    type: complex
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: delay
    type: complex
  states: {state: disabled}
- name: pad_source_1
  id: pad_source
  parameters:
    label: fir_filter
    type: complex
  states: {state: disabled}
- name: pad_source_2
  id: pad_source
  parameters:
    label: divide
    type: float
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: Post-Equalizer
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Pre-Equalizer
    size: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: LO_freq
    fftsize: '1024'
    name: '"Sync Long - Output"'
    rate: update_time
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: LO_freq
    fftsize: '1024'
    name: '"Sync Short - Output"'
    rate: update_time
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: LO_freq
    fftsize: '1024'
    name: '"Input"'
    rate: update_time
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Autocorrelation Samples
    size: '512'
    srate: '1'
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '0'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_mag_1_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0, '0', pad_sink_0_0_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', pad_sink_0, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0, '0', ieee802_11_sync_short_0, '1']
- [fir_filter_xxx_0, '0', pad_sink_0_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_divide_xx_0, '1']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_sync_long_0, '0', blocks_complex_to_mag_1, '0']
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_complex_to_mag_1_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [iio_pluto_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0_0, '0', blocks_multiply_xx_0, '1']
- [iio_pluto_source_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [pad_source_0, '0', ieee802_11_sync_short_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
